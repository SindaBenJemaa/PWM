<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>C:\Users\Sinda\Downloads\EWARM\23-24.ewp</path>
    </project>
    <batchBuild />
</workspace>
